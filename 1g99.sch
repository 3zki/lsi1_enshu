v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 260 -220 0 0 {name=p1 lab=A}
C {devices/ipin.sym} 260 -180 0 0 {name=p2 lab=B}
C {devices/ipin.sym} 260 -140 0 0 {name=p3 lab=C}
C {devices/ipin.sym} 260 -100 0 0 {name=p4 lab=D}
C {devices/opin.sym} 420 -150 0 0 {name=p5 lab=Y}
C {devices/vdd.sym} 360 -260 0 0 {name=l1 lab=VDD}
C {devices/gnd.sym} 360 -40 0 0 {name=l2 lab=GND}
